# Keil uVision project 15f104w.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: 15f104w +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c softuart.c softuart.h translate.c translate.h
